# Keil uVision project HTTP_Server.uvprojx, settings and files
target MCB4300 (6160000::V6.16::ARMCLANG)
  device: LPC4357:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.10.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x12000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(204000000) ELITTLE
  output: HTTP_Server
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x2000f800 size 0x800
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0xf800
  scatter file: .\lpc4357.sct
  group App
    ./: HTTP_Server.c HTTP_Server.h HTTP_Server_CGI.c
    Web/: Web.c
  group Board
    ./: main.c main.h lpc4357.sct
  group Board IO
    ./Board_IO/: vio_MCB4300.c
  group Web files
    ./Web/: index.htm pg_header.inc pg_footer.inc ad.cgi ad.cgx buttons.cgi buttons.cgx language.cgi lcd.cgi leds.cgi network.cgi system.cgi tcp.cgi xml_http.js home.png keil.gif llblue.jpg logo.gif pabb.gif
  group Documentation
    ./: README.md
software components: CMSIS Driver:VIO:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:A/D Converter 1.0.0, Board Support:Buttons 1.0.0, Board Support:Graphic LCD 1.0.0, Board Support:LED 1.0.0, Network:CORE 7.15.5, Network:Interface:ETH 7.15.5, Network:Service:Web Server Compact 7.15.5, Network:Socket:TCP 7.15.5, Network:Socket:UDP 7.15.5, CMSIS Driver:CAN 1.6.0, CMSIS Driver:Ethernet MAC 2.13, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:I2C 2.8, CMSIS Driver:MCI 2.8, CMSIS Driver:SAI:I2S 1.7, CMSIS Driver:SPI:SSP 2.12, CMSIS Driver:USART 2.17, CMSIS Driver:USB Device:USB0 2.12, CMSIS Driver:USB Host:USB0 2.6, Device:GPDMA 1.6, Device:GPIO 1.1, Device:SCU 1.2, Device:Startup 1.0.0
